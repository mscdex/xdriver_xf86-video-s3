## Config.in
```kconfig
config BR2_PACKAGE_XDRIVER_XF86_VIDEO_S3
  bool "xf86-video-s3"
  select BR2_PACKAGE_XORGPROTO
  help
    X.Org driver for s3 cards
```
